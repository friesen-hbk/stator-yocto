inherit hbk-base