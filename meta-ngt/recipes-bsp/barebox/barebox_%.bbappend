SRCREV = "a999dc558770732d475e423060d54b93e36436ce"

SRC_URI = "file://

"
do_configure_prepend() {
		       bbwarn ("---- > ${WORKDIR}")
cp bla.txt /tmp/bub


}
