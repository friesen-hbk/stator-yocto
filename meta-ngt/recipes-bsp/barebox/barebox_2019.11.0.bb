require barebox.inc

SRC_URI[md5sum] = "45bf108b22de94a73dfe5c024c873486"
SRC_URI[sha256sum] = "607165b96d98fcc114fbd07e4001e7b527739a543e7adbe019854fbd8c78777f"
